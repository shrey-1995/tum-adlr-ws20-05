Commit message: Removed table

File: bullet3/examples/pybullet/gym/pybullet_data/table/table.urdf (robot description, URDF)
Before this commit: robot table.urdf, 1 links, 0 joints
Links:
- link baseLink: geometry collision box size=0 0 0; visual mesh filename=table.obj scale=0.1 0.1 0.58
